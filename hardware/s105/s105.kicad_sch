File: hardware/s105/s105.kicad_sch (KiCad schematic)
At the start: 28 parts, among them P1 368255-2

Commit message: #4 #5 #6 #8
Other:
- company: (none) -> rusEFI
- title: (none) -> s105
